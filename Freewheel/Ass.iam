# Autodesk Inventor assembly: LapCBr
## iProperties
Created: 2010-09
Part Number: LapCBr
Document SubType Name: Assembly
Designer: nguyenducthang
Author: nguyenducthang
